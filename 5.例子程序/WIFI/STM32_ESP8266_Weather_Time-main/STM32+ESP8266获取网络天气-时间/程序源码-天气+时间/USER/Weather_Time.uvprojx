# Keil uVision project Weather_Time.uvprojx, settings and files
target Weather_Time (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Weather_Time +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\cJSON;..\MALLOC;..\HARDWARE\ESP8266;..\HARDWARE\24CXX;..\HARDWARE\RTC;..\HARDWARE\WDG;..\HARDWARE\IIC;..\HARDWARE\TIMER;..\TEXT;..\HARDWARE\W25QXX
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/ESP8266/: wifista.c weather.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TIMER/: timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_wwdg.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_sdio.c stm32f10x_iwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
  group CJSON
    ../cJSON/: parsejson.c utf8togbk.c
  group README
    ../: README.TXT
